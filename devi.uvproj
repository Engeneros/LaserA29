# Keil uVision project devi.uvproj, settings and files
target device (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ..\hex\devi +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: LPC2148
  c include: .\code;.\code\UART;.\code\Encoder;.\code\ButtLed;.\code\SSPDevices;.\code\Display;.\code\Temperature;.\code\uI;.\code\IAP;.\code\Converter
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Common
    ./code/: Startup.s mainFile.cpp Delay.cpp uC.cpp
  group board
    ./code/: BoardLdCtl4.cpp
  group Encoder
    ./code/Encoder/: Encoders.cpp
  group ButtLed
    ./code/ButtLed/: LEDs.cpp Buttons.cpp
  group SSPDevices
    ./code/SSPDevices/: SerialIO.cpp
  group Display
    ./code/Display/: Displays.cpp
  group TMetr
    ./code/Temperature/: TMetr.cpp
  group Interface
    ./code/uI/: UInterfaces.cpp
  group IAP
    ./code/IAP/: iap.cpp
  group Converter
    ./code/Converter/: Converters.cpp
